# Keil uVision project TQ2440_Test.uvproj, settings and files
target ram_or_nand (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: TQ2440_Test +hex
  AfterMake: fromelf.exe --bin -o @p.bin output/@p.axf
  c flags: Optim=1
  c include: .\inc;..\..\m4toarm;.\fatfs
  asm include: .\inc
  memory RVCT1: ROM 0x30000000 size 0x800000
  memory RVCT6: RAM 0x30800000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x800000
  link misc: --sort=CallTree
  group inc
    ./inc/: 2440addr.h 2440addr.inc 2440lib.h 2440slib.h 2440usb.h AudioDrv.h bootpara.h camdata.h camdef.h camif.h camproset.h def.h dma.h IIC.h keyscan.h LCD_TFT.h MAIN.h Memcfg.inc memtest.h mmu.h Nand.h norflash.h Option.h Option.inc profile.h SD_MMC.h Test_OV9650.h Wav_source.h menu.h DisplayBmp.h
  group src
    ./src/: UDA1341.c SD_MMC.c profile.c nand.c mmu.c memtest.c Main.c LCD_TFT.c keyscan.c dma.c AudioDrv.c Adc.c 2440slib.s 2440lib.c 2440init.s InfoNES_system.c picture.c Touchpanel.c menu.c Font_Libs.c DisplayBmp.c
  group nes
    ../: InfoNES.cpp InfoNES_Mapper.cpp InfoNES_pAPU.cpp K6502.cpp
  group fatfs
    ./fatfs/: diskio.c ff.c
    ./fatfs/option/: cc936.c
target nor (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: TQ2440_Test +hex
  AfterMake: fromelf.exe --bin -o @p.bin output/@p.axf
  c flags: Optim=1
  c include: .\inc
  asm include: .\inc
  memory RVCT1: ROM 0x0 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x800000
  memory RVCT9: RAM 0x40000000 size 0x1000
  link misc: --sort=CallTree
